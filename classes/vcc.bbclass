inherit vcc_base
inherit vcc_package_deploy
inherit vcc_make_release
inherit vcc_create_manifest


addhandler vcc_eventhandler
python vcc_eventhandler() {
    from bb.event import getName
    import pip
    import importlib
    import sys
    import site

    if getName(e) == "ConfigParsed":

        if not os.path.exists(site.USER_SITE):
            os.makedirs(site.USER_SITE)
        
        sys.path.insert(0, site.USER_SITE)

        try:
            importlib.import_module("yaml")
        except ImportError:
            pip.main(['install', "pyyaml"])

        # load the config files from meta layer folders 
        conf_dict = load_yaml_files_from_layer_paths(d)
        # load the config from meta-rdk-vcc/manifests
        load_meta_layer_yaml_files(d, conf_dict)
        d.setVar("YAML_CONFIG", conf_dict)

        # Download all Packages files and combine them into a
        # single 'Packages' file in WORKDIR
        init_package_index_data(d)
        #d.setVar("BB_DONT_CACHE", "1")

    if getName(e) == "RecipePreFinalise":
        #Update the package revision value to remove the
        #strings like commit ids to avoid version check errors
        #during dependency processing.
        pkgv = d.getVar("PKGV", True)
        d.setVar("PKGV", pkgv.split("+")[0])
        if bb.data.inherits_class("packagegroup", d):
            set_task_dep(d, "do_make_layer_release", "do_build")
            set_task_dep(d, "do_make_dev_release", "do_build")
        pn = d.getVar("PN")
      
        yaml_config = get_recipe_yaml_conf(d, pn)[1]
        if yaml_config != None:
            recipe = yaml_config['Recipes'][pn]
            
            build = validate_key(recipe, 'Build')
            clean_recipe_state(d, build)
            # The devtool_checkout_source_mode may be set from devtool checkout command, in that case
            # the package must be processed in source build mode.
            src_mode_override = d.getVar("devtool_checkout_source_mode", True)
            if build == True:
                pv = d.getVar("PV", True)
                if pv == "1.0":
                    recipe_version_from_file = bb.parse.vars_from_file(d.getVar('FILE', False),d)[1]
                    if recipe_version_from_file == None:
                        d.setVar("PV", "1.0.0")
                    
                if (src_mode_override != None and src_mode_override == pn):
                    # Add the below function to make sure to delete 
                    # the ipk files that are generated by the last build, this is to avoid build breakage
                    # when build mode is switched from package to source.
                    vcc_inject_function(d, "do_package_write_ipk_setscene", "prefuncs", "remove_ipk_from_deploy")
                    vcc_inject_function(d, "do_package_write_ipk", "prefuncs", "remove_ipk_from_deploy")
                    # Disable the vcc tasks as they are applicable only if the build is false
                    disable_task(d, "do_vccprocess")
                    disable_task(d, "do_vccprocess_sdk")
                
            else: # build is false
                if (src_mode_override != None and src_mode_override == pn):
                    # Set the yaml section for source mode if it was in package mode
                    vcc_set_source_mode(d) # yaml build true
                ipk_dict = get_recipe_section_from_index_file(d, pn)
                if ipk_dict:
                    version = validate_key(recipe, 'Version')
                    if version != None:
                        setup_package_url(d, ipk_dict, version)
                    else:
                        bb.error("No version specified for recipe %s in yaml file." % pn)
                        return

                    # Set the sha256sum for ipks
                    for ipk_name, sha256sum in ipk_dict.items():
                        e.data.setVarFlag("SRC_URI", "%s.sha256sum"%ipk_name, sha256sum)
                    updated_recipes = get_updated_recipes_list(d)
                    if updated_recipes:
                        bb.warn("updated_recipes=%s" % updated_recipes)
                    if pn in updated_recipes:
                        force_update_ipk(d, pn)
                else:
                    bb.error("No ipk files found for recipe %s in the index file." % pn)
                    
                do_vcc_pkg_mode(d, recipe)
    
    if getName(e) == "TaskSucceeded":
        if e.task == "do_prepare_recipe_sysroot":
            # Create the yaml section for recipe in source mode.
            pn = d.getVar("PN", True)
            create_yaml_section_src_mode(d, pn)
        elif e.task == "do_package_write_ipk":
            # Set Build to false for the recipes since packages were created
            update_component_yaml_build_flag(d.getVar("PN", True), False)
}

vcc_eventhandler[eventmask] = "bb.event.ConfigParsed bb.event.RecipePreFinalise bb.build.TaskSucceeded"
